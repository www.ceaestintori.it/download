Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Fire-Products_Protection_Cea-Estintori_PD6ES.ifc
Time: 2020-10-02T17:36:13
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, PD6ES
ePset_BIMobjectScript - Signage Type: Off; Mount Type: Off; LOD: 300; Wall Sign Width: 250; Wall Sign Height: 310
ePset_BIMobject_BO - ProductName (BO_prodinfo): PD6ES; SKU (BO_prodsku): PD6ES; ManufacturName (BO_Manufac): Cea Estintori; ProductFamily (BO_prodfam): Estintori portatili; ProductGroup (BO_prodgroup): A polvere; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/cea-estintori/product/PD6ES; ProductDataUrl (BO_prodaturl): bimobject.com/cea-estintori/product/PD6ES; MaterialMain (BO_mainmat): Metal; MaterialSecondary (BO_secmat): Plastic; BimObjectMainCategory (BO_bomaincat): Fire Products; BimObjectMainCategoryCode (BO_bomaincat_code): fire-products; BimObjectCategory (BO_bocat): Protection; BimObjectCategoryCode (BO_bocat_code): fire-protection; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 46191601; Uniclass14Code (BO_uniclass_1_4_code): L881; Uniclass14Description (BO_uniclass_1_4_desc): Fire extinguishers; Uniclass20Code (BO_uniclass_2_0_code): PR-35-28-96; Uniclass20Description (BO_uniclass_2_0_desc): Water Fire Extinguishers; Uniclass2015Code (BO_uniclass2015_code): Ss_55_30_65; Uniclass2015Description (BO_uniclass2015_desc): Portable fire extinguishing systems; NBSReference (BO_nbs_ref): 35-28-96; NBSReferenceDescription (BO_nbs_desc): Water Fire Extinguishers; OmniClassCode (BO_omniclass_code): 23-29 25 19; OmniClassDescription (BO_omniclass_name): Fire Extinguishers; MasterFormat2014Code (BO_masterformat2014_code): 10 44 16; MasterFormat2014Description (BO_masterformat2014_name): Fire Extinguishers; UniFormat2Code (BO_uniformat2_code): D40; UniFormat2Description (BO_uniformat2_name): FIRE PROTECTION; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
